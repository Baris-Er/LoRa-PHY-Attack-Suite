options:
  parameters:
    generate_options: qt_gui
    id: Selective_replay_attack
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 868.125e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import os
      import numpy as np
      from gnuradio import gr

      class segment_threshold_recorder(gr.sync_block):
          """
          This block processes the incoming IQ stream by:
            - Splitting the data into 0.5-second segments.
            - If any sample in a segment exceeds a certain (linear) threshold,
              that segment is considered part of a message.
            - If no sample in the segment is above the threshold, and there was an ongoing recording,
              that segment marks the end of the message. The message is then saved to disk with a dynamic filename
              (e.g., msg_0.dat, msg_1.dat, …).
            - After that, it resumes searching for a new message.
          """
          def __init__(self, threshold=0.300, samp_rate=2.4e6, output_dir=r"C:\Users\hakan\Documents\lora_recordings"):
              gr.sync_block.__init__(
                  self,
                  name="segment_threshold_recorder",
                  in_sig=[np.complex64],
                  out_sig=[]
              )
              self.threshold = threshold
              self.samp_rate = int(samp_rate)
              self.segment_duration = 0.5
              self.chunk_size = int(self.samp_rate * self.segment_duration)
              self.output_dir = output_dir
              os.makedirs(self.output_dir, exist_ok=True)

              self.recording = False
              self.current_message = []
              self.segment_buffer = []
              self.msg_count = 0

          def work(self, input_items, output_items):
              in0 = input_items[0]
              self.segment_buffer.extend(in0)

              while len(self.segment_buffer) >= self.chunk_size:
                  segment = np.array(self.segment_buffer[:self.chunk_size], dtype=np.complex64)
                  self.segment_buffer = self.segment_buffer[self.chunk_size:]

                  if np.any(np.abs(segment) > self.threshold):
                      if not self.recording:
                          self.recording = True
                          self.current_message = []
                      self.current_message.append(segment)
                  else:
                      if self.recording:
                          full_message = np.concatenate(self.current_message)
                          filename = os.path.join(self.output_dir, f"msg_{self.msg_count}.dat")
                          self.msg_count += 1
                          with open(filename, "wb", buffering=0) as f:
                              full_message.tofile(f)
                          self.recording = False
                          self.current_message = []

              return len(in0)
    output_dir: '''C:\\Users\\hakan\\Documents\\lora_recordings'''
    samp_rate: samp_rate
    threshold: '0.300'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import os\nimport numpy as np\nfrom gnuradio import gr\nfrom PyQt5 import QtWidgets, QtCore\n\nclass gui_file_source(gr.sync_block):\n    \"\"\"\n    This block creates a GUI (combo box, refresh button, and send button) listing message files \n    (msg_*.dat or msg_*.bin) in the specified directory (e.g., \"C:\\\\Users\\\\hakan\\\\Documents\\\\lora_recordings\"). \n    Once the user selects a file and clicks the \"Send\" button, the file is read via np.fromfile() and replayed \n    as an IQ (np.complex64) stream. After the entire file has been sent (when replay is finished), \n    the block produces zero (0) samples and waits for a new selection.\n    \"\"\"\n    def __init__(self, directory=r\"C:\\Users\\hakan\\Documents\\lora_recordings\"):\n        gr.sync_block.__init__(\n            self,\n            name=\"gui_file_source\",\n            in_sig=None,\n            out_sig=[np.complex64]\n        )\n        self.directory = directory\n        self.data = None\n        self.pointer = 0\n        self.file_selected = False\n        self.pending_file = None\n        QtCore.QTimer.singleShot(0, self._init_gui)\n\n    def _init_gui(self):\n        app = QtWidgets.QApplication.instance()\n        if app is None:\n            app = QtWidgets.QApplication([])\n        self.widget = QtWidgets.QWidget()\n        self.widget.setWindowTitle(\"Mesaj Dosyası Seçici\")\n        layout = QtWidgets.QHBoxLayout(self.widget)\n        self.combo = QtWidgets.QComboBox(self.widget)\n        self.refresh_button = QtWidgets.QPushButton(\"Yenile\", self.widget)\n        self.send_button = QtWidgets.QPushButton(\"Gönder\", self.widget)\n        layout.addWidget(self.combo)\n        layout.addWidget(self.refresh_button)\n        layout.addWidget(self.send_button)\n        self.widget.setLayout(layout)\n        self.refresh_button.clicked.connect(self.refresh_files)\n        self.combo.currentIndexChanged.connect(self.selection_changed)\n        self.send_button.clicked.connect(self.send_file)\n        self.refresh_files()\n        self.widget.show()\n\n    def refresh_files(self):\n        self.combo.clear()\n        try:\n            files = [\n                f for f in os.listdir(self.directory)\n                if f.startswith(\"msg_\") and (f.endswith(\".dat\") or f.endswith(\".bin\"))\n            ]\n            files.sort()\n            self.combo.addItems(files)\n        except Exception as e:\n            print(\"Error listing files:\", e)\n\n    def selection_changed(self, index):\n        if index < 0:\n            return\n        filename = self.combo.itemText(index)\n        full_path = os.path.join(self.directory, filename)\n        self.pending_file = full_path\n        print(\"Selected file, click 'Gönder' to send:\", full_path)\n\n    def send_file(self):\n        if self.pending_file is not None:\n            print(\"Send button clicked. Loading file:\", self.pending_file)\n            self.load_file(self.pending_file)\n        else:\n            print(\"Send button clicked but no file selected.\")\n\n    def load_file(self, file_path):\n        if os.path.exists(file_path) and os.path.isfile(file_path):\n            try:\n                self.data = np.fromfile(file_path, dtype=np.complex64)\n                self.pointer = 0\n                self.file_selected = True\n                print(\"File loaded:\", file_path, \"Number of samples:\", len(self.data))\n            except Exception as e:\n                print(\"Error loading file:\", e)\n                self.data = None\n                self.file_selected = False\n        else:\n            print(\"File does not exist:\", file_path)\n            self.data = None\n            self.file_selected = False\n\n    def work(self, input_items, output_items):\n        out = output_items[0]\n        n_out = len(out)\n        if self.data is None or not self.file_selected:\n            out[:] = np.zeros(n_out, dtype=np.complex64)\n            return n_out\n        remaining = len(self.data) - self.pointer\n        if remaining >= n_out:\n            out[:] = self.data[self.pointer:self.pointer+n_out]\n            self.pointer += n_out\n            if self.pointer >= len(self.data):\n                print(\"File transmission completed.\")\n                self.file_selected = False\n            return n_out\n        else:\n            out[:remaining] = self.data[self.pointer:]\n            out[remaining:] = np.zeros(n_out - remaining, dtype=np.complex64)\n            self.pointer = len(self.data)\n            print(\"File transmission completed.\")\n            self.file_selected = False\n            return n_out\n\n\n"
    directory: '''C:\\Users\\hakan\\Documents\\lora_recordings'''
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 360e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 120e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0
    bb_gain0: '30'
    freq0: center_freq
    gain0: '30'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: rtl=0,direct_sampling=0
    bb_gain0: '20'
    freq0: center_freq
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [epy_block_1, '0', osmosdr_sink_0_0, '0']
- [low_pass_filter_1, '0', epy_block_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
